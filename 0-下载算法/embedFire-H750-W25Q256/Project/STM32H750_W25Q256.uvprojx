# Keil uVision project STM32H750_W25Q256.uvprojx, settings and files
target STM32H750_W25Q256 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: embedFire-H750V-W25Q256-SDRAM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: W25Q256FV,STM32H750xx,USE_HAL_DRIVER,VECT_TAB_SRAM
  c include: ..\Libraries\STM32H7xx_HAL_Driver\Inc;..\User;..\CMSIS\Include;..\CMSIS\Device\ST\STM32H7xx\Include;..\User\FlashAPI;..\User\BSP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group STARTUP
    ../User/: system_stm32h7xx.c
    ../CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Program Functions
    ../User/FlashAPI/: Bootloader.c FlashPrg.c
  group Device Description
    ../User/FlashAPI/: FlashDev.c
  group HAL
    ../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_gpio.c
  group QSPI
    ../User/BSP/: bsp_led.c bsp_debug_usart.c bsp_qspi_flash.c
  group device
    ../User/: main.c stm32h7xx_it.c
target algorithm_debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: as above
  output: embedFire-H750-W25Q256x2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,VECT_TAB_SRAM,Debug
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
