# Keil uVision project STM32H750_W25Q256x2.uvprojx, settings and files
target STM32H750_W25Q256x2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: embedFire-H750-W25Q256-SDRAM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: W25Q256FV,STM32H750xx,USE_HAL_DRIVER
  c include: .\STM32H7xx_HAL_Driver\Inc;.\STM32H7xx_HAL_Driver\Inc\Legacy;..\embedFire-H750-W25Q256x2;.\Include;..\embedFire-H750-W25Q256x2_read_write20190318_testok;.\CMSIS\Device\ST\STM32H7xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c Bootloader.c
  group Device Description
    ./: FlashDev.c
  group HAL
    ./STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c
    ./: system_stm32h7xx.c
  group QSPI
    ./: FlashSTM32H7xx_QSPI.c
  group device
    ./: startup_stm32h743xx.s main.c bsp_led.c bsp_debug_usart.c stm32h7xx_it.c
    ./STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_uart_ex.c
target READ_WRITE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: embedFire-H750-W25Q256x2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: .\STM32H7xx_HAL_Driver\Inc;.\STM32H7xx_HAL_Driver\Inc\Legacy;..\embedFire-H750-W25Q256x2;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
